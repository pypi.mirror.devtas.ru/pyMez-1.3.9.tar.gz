! Channel 1
! Ports=123
! Points=2329
! Topology=ALL_SE(123)
# Hz S RI R 50
! Worked out from all points (3-port):
!   2329 points, 10 Hz to 12.08 kHz, reference 50 ohm
!   strongest paths, dB at 10 Hz, 2.504 kHz, 4.222 kHz, 7.132 kHz, 12.08 kHz:
!     S32: 42.5, 36.7, 39.6, 42.5, 42.7
!     S31: 44.1, 42.4, 42.0, 33.6, 44.2
!     S21: 36.6, 43.7, 35.4, 37.6, 23.9
!   lowest |S11| = -1.8 dB at 10 Hz (marker M1), VSWR 9.81, Z = 9.11 - j43.9 ohm
!   |S11| at or under -10 dB: nowhere
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! magnitudes (dB):
! f  S11  S32  S31  S21
! 10 Hz  -1.8  42.5  44.1  36.6
! 670 Hz  35.6  34.1  36.9  33.2
! 1.38 kHz  41.2  36.0  43.7  44.4
! 2.035 kHz  43.9  45.1  38.1  45.1
! 4.837 kHz  38.2  36.6  39.5  43.5
! 5.437 kHz  31.1  44.5  36.5  40.6
! 6.047 kHz  37.5  35.1  43.1  31.6
! 6.787 kHz  41.7  41.2  40.0  43.3
! 7.712 kHz  26.9  36.9  39.4  33.1
! 12.08 kHz  30.2  42.7  44.2  23.9
