# GHZ S RI R 50
! Worked out from all points (weakly coupled two-port):
!   2281 points, 10 GHz to 67 GHz, reference 50 ohm
!   highest |S21| = -19.92 dB at 10 GHz (marker M1); lowest = -64.8 dB at 67 GHz (marker M2)
!   lowest |S11| = -47.8 dB at 10.53 GHz (marker M3), VSWR 1.01, Z = 50.4 + j0.08 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -63.7 to -20.6 dB; largest |S21 - S12| = 0.0005
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 GHz  -41.2  -19.9  -19.9  -41.8
! 10.38 GHz  -35.3  -20.3  -20.3  -41.2
! 10.53 GHz  -47.8  -20.5  -20.5  -52.9
! 11.93 GHz  -40.1  -22.0  -22.0  -37.9
! 13.28 GHz  -42.2  -23.4  -23.4  -36.5
! 15.43 GHz  -38.1  -25.5  -25.5  -59.6
! 16.8 GHz  -34.9  -26.8  -26.7  -37.1
! 19.5 GHz  -34.1  -29.2  -29.2  -30.7
! 22.2 GHz  -31.7  -31.5  -31.5  -33.1
! 26.43 GHz  -30.8  -35.0  -35.0  -25.1
! 29 GHz  -31.3  -37.0  -37.0  -29.0
! 30.43 GHz  -31.7  -38.1  -38.1  -30.5
! 34.23 GHz  -32.9  -41.0  -41.0  -24.3
! 37.45 GHz  -30.4  -43.4  -43.3  -31.2
! 38.5 GHz  -30.4  -44.1  -44.1  -31.9
! 41.25 GHz  -29.5  -46.2  -46.1  -28.1
! 44.17 GHz  -26.1  -48.2  -48.2  -29.1
! 48 GHz  -25.9  -51.2  -50.9  -23.5
! 51.17 GHz  -25.0  -53.2  -53.1  -26.3
! 54.6 GHz  -26.5  -55.4  -55.5  -21.0
! 57.5 GHz  -26.5  -57.9  -57.3  -24.0
! 67 GHz  -22.6  -64.8  -63.9  -21.7
