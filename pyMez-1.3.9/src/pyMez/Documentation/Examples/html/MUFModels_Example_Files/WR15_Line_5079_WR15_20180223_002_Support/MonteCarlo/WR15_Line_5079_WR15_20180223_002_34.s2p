# GHZ S RI R 50
! Worked out from all points (through path):
!   251 points, 50 GHz to 75 GHz, reference 50 ohm
!   highest |S21| = 1.08 dB at 52.9 GHz (marker M1); lowest = -0.8 dB at 52.8 GHz (marker M2)
!   lowest |S11| = - dB at 50 GHz (marker M3), VSWR 1.00, Z = 50 + j1.97e-16 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from - to - dB; largest |S21 - S12| = 1e-14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 GHz  -  0.4  0.4  -
! 51.8 GHz  -  -0.1  -0.1  -
! 52.4 GHz  -  0.5  0.5  -
! 52.5 GHz  -  -0.2  -0.2  -
! 52.7 GHz  -  0.5  0.5  -
! 52.8 GHz  -  -0.8  -0.8  -
! 52.9 GHz  -  1.1  1.1  -
! 53 GHz  -  -0.2  -0.2  -
! 53.2 GHz  -  0.6  0.6  -
! 53.7 GHz  -  -0.2  -0.2  -
! 53.8 GHz  -  0.8  0.8  -
! 54.2 GHz  -  0.2  0.2  -
! 57.9 GHz  -  0.6  0.6  -
! 58.4 GHz  -  0.0  0.0  -
! 58.5 GHz  -  0.6  0.6  -
! 62.5 GHz  -  0.3  0.3  -
! 66.7 GHz  -  0.3  0.3  -
! 69.1 GHz  -  0.1  0.1  -
! 69.3 GHz  -  0.9  0.9  -
! 69.4 GHz  -  0.1  0.1  -
! 70.9 GHz  -  0.5  0.5  -
! 75 GHz  -  0.4  0.4  -
