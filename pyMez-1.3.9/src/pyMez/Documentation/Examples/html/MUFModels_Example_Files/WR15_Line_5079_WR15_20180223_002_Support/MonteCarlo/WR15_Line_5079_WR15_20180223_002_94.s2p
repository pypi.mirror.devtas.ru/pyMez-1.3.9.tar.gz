# GHZ S RI R 50
! Worked out from all points (through path):
!   251 points, 50 GHz to 75 GHz, reference 50 ohm
!   highest |S21| = 0.86 dB at 74.3 GHz (marker M1); lowest = -1.5 dB at 52.8 GHz (marker M2)
!   lowest |S11| = - dB at 50 GHz (marker M3), VSWR 1.00, Z = 50 + j1.72e-15 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from - to - dB; largest |S21 - S12| = 1e-14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 GHz  -  -0.4  -0.4  -
! 52.4 GHz  -  -0.2  -0.2  -
! 52.5 GHz  -  -0.8  -0.8  -
! 52.7 GHz  -  -0.1  -0.1  -
! 52.8 GHz  -  -1.5  -1.5  -
! 52.9 GHz  -  0.5  0.5  -
! 53 GHz  -  -0.9  -0.9  -
! 53.2 GHz  -  0.0  0.0  -
! 53.7 GHz  -  -0.8  -0.8  -
! 53.8 GHz  -  0.3  0.3  -
! 54.2 GHz  -  -0.3  -0.3  -
! 58.4 GHz  -  -0.4  -0.4  -
! 58.5 GHz  -  0.2  0.2  -
! 62.5 GHz  -  0.0  0.0  -
! 66.7 GHz  -  0.1  0.1  -
! 70.9 GHz  -  0.4  0.4  -
! 73.4 GHz  -  0.0  0.0  -
! 73.5 GHz  -  0.7  0.7  -
! 73.7 GHz  -  0.0  0.0  -
! 74.3 GHz  -  0.9  0.9  -
! 74.5 GHz  -  0.0  0.0  -
! 75 GHz  -  0.4  0.4  -
