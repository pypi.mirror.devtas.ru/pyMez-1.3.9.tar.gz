# GHZ S RI R 50
! Worked out from all points (through path):
!   251 points, 50 GHz to 75 GHz, reference 50 ohm
!   highest |S21| = 0.31 dB at 52.9 GHz (marker M1); lowest = -2.8 dB at 74.5 GHz (marker M2)
!   lowest |S11| = - dB at 50 GHz (marker M3), VSWR 1.00, Z = 50 - j2.92e-15 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from - to - dB; largest |S21 - S12| = 2e-15
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 GHz  -  -0.2  -0.2  -
! 52.4 GHz  -  -0.3  -0.3  -
! 52.5 GHz  -  -1.1  -1.1  -
! 52.7 GHz  -  -0.3  -0.3  -
! 52.8 GHz  -  -1.8  -1.8  -
! 52.9 GHz  -  0.3  0.3  -
! 53 GHz  -  -1.1  -1.1  -
! 53.2 GHz  -  -0.2  -0.2  -
! 54.2 GHz  -  -0.8  -0.8  -
! 58.4 GHz  -  -1.4  -1.4  -
! 62.5 GHz  -  -1.5  -1.5  -
! 66.7 GHz  -  -1.9  -1.9  -
! 70.9 GHz  -  -1.9  -1.9  -
! 72.4 GHz  -  -1.7  -1.7  -
! 73 GHz  -  -2.6  -2.6  -
! 73.2 GHz  -  -1.8  -1.8  -
! 73.4 GHz  -  -2.7  -2.7  -
! 73.5 GHz  -  -1.7  -1.7  -
! 73.7 GHz  -  -2.7  -2.7  -
! 74.3 GHz  -  -1.6  -1.6  -
! 74.5 GHz  -  -2.8  -2.8  -
! 75 GHz  -  -2.3  -2.3  -
